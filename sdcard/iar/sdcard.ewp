# IAR project sdcard.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32GG990F1024 EnergyMicro EFM32GG990F1024
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: EFM32GG990F1024
  ICCARM.CCIncludePath2: ../src; ../CMSIS/Include; ../emlib/inc; ../Device/EnergyMicro/EFM32GG/Include; ../FatFS
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../src; ../CMSIS/Include; ../emlib/inc; ../Device/EnergyMicro/EFM32GG/Include
  OBJCOPY.OOCOutputFile: sdcard.bin
  ILINK.IlinkOutputFile: sdcard.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; EFM32GG990F1024
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32GG990F1024.icf
  group Application
    ../src/: sdcard.c
  group autogen
    ../src/: autogen_init.c
  group CMSIS
    ../Device/EnergyMicro/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../Device/EnergyMicro/EFM32GG/Source/: system_efm32gg.c
  group emlib
    ../emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_idac.c em_int.c em_lcd.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
  group FatFS
    ../FatFS/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
